<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fccWatch</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>1/float(decimation_post)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>np.max(fccFreqs)-np.min(fccFreqs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>(np.max(fccFreqs)+np.min(fccFreqs))/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_post</value></param>
<param><key>value</key><value>int(np.round(spec_samp_rate_pre/spec_samp_rate_post))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_pre</value></param>
<param><key>value</key><value>int(np.round(samp_rate/fft_len/spec_samp_rate_pre))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fccFreqNames</value></param>
<param><key>value</key><value>[('_' + s + 'M').replace('.','_') for s in map(str,(fccFreqs*1e-6))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fccFreqs</value></param>
<param><key>value</key><value>1e6*np.array([461.025,461.075,461.1,462.155,462.375,462.4,464.5,464.55,464.6,464.625,464.65,464.725,464.75])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>indices</value></param>
<param><key>value</key><value>np.round((fccFreqs - center_freq)*fft_len/samp_rate+fft_len/2).astype(int)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_samp_rate_post</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_samp_rate_pre</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>waterfall_max</value></param>
<param><key>value</key><value>-82</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>waterfall_min</value></param>
<param><key>value</key><value>-93</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>n</key><value>decimation_pre</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>maxoutbuf</key><value>64</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxoutbuf</key><value>10</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>monitor_extract_bins</key>
<param><key>id</key><value>monitor_extract_bins_0</value></param>
<param><key>indices</key><value>indices</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>vlen_in</key><value>fft_len</value></param>
<param><key>weights</key><value>[0.3, 0.3, 0.3]</value></param>
</block>
<block>
<key>monitor_vec2sqlite</key>
<param><key>id</key><value>monitor_vec2sqlite_0</value></param>
<param><key>column_names</key><value>fccFreqNames</value></param>
<param><key>filename</key><value>/home/samcarey/rfnoc/src/gr-monitor/examples/fccFreqs0.db</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_rows</key><value>300</value></param>
<param><key>table_name</key><value>table1</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-55</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>fft_len</value></param>
<param><key>int_max</key><value>waterfall_max</value></param>
<param><key>int_min</key><value>waterfall_min</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>spr_vec_iir</key>
<param><key>id</key><value>spr_vec_iir_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>31.5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"type=b200"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>monitor_extract_bins_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>monitor_vec2sqlite_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>monitor_extract_bins_0</source_block_id><sink_block_id>spr_vec_iir_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spr_vec_iir_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
