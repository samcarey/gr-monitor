<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fccWatch</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>1/float(decimation_post)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>np.max(fccFreqs)-np.min(fccFreqs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>(np.max(fccFreqs)+np.min(fccFreqs))/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>database_GB</value></param>
<param><key>value</key><value>max_entries*10.5*1e-9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_post</value></param>
<param><key>value</key><value>int(np.round(spec_samp_rate_pre/spec_samp_rate_post))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_pre</value></param>
<param><key>value</key><value>int(np.round(samp_rate/fft_len/spec_samp_rate_pre))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fccFreqNames</value></param>
<param><key>value</key><value>[('_' + s + 'M').replace('.','_') for s in map(str,(fccFreqs*1e-6))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fccFreqs</value></param>
<param><key>value</key><value>1e6*np.array([461.025,461.075,461.1,462.155,462.375,462.4,464.5,464.55,464.6,464.625,464.65,464.725,464.75])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>indices</value></param>
<param><key>value</key><value>np.round((fccFreqs - center_freq)*fft_len/samp_rate+fft_len/2).astype(int)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_entries</value></param>
<param><key>value</key><value>max_rows*len(fccFreqs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_hours</value></param>
<param><key>value</key><value>24*7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_rows</value></param>
<param><key>value</key><value>max_hours*60*60*spec_samp_rate_pre</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_samp_rate_post</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_samp_rate_pre</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>n</key><value>decimation_pre</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>maxoutbuf</key><value>1024</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxoutbuf</key><value>10</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>monitor_extract_bins</key>
<param><key>id</key><value>monitor_extract_bins_0</value></param>
<param><key>indices</key><value>indices</value></param>
<param><key>maxoutbuf</key><value>8</value></param>
<param><key>vlen_in</key><value>fft_len</value></param>
<param><key>weights</key><value>[0.3, 0.3, 0.3]</value></param>
</block>
<block>
<key>monitor_vec2sqlite</key>
<param><key>id</key><value>monitor_vec2sqlite_0</value></param>
<param><key>column_names</key><value>fccFreqNames</value></param>
<param><key>filename</key><value>/home/pi/fccFreqs.db</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_rows</key><value>max_rows</value></param>
<param><key>table_name</key><value>table1</value></param>
<param><key>vlen</key><value>len(indices)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>31.5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"type=b200"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>monitor_extract_bins_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>monitor_vec2sqlite_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>monitor_extract_bins_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
